<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>QuadroHT15_v2-1 Configuration</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings>
          <package checked="" name="">
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
          </package>
          <package checked="" name="">
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
          </package>
          <package checked="" name="">
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
          </package>
          <package checked="" name="">
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
          </package>
        </cstatsettings>
      </data>
    </settings>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\CMSIS\Device\ST\STM32F3xx\Source\Templates\iar\startup_stm32f303xc.s</name>
      </file>
    </group>
    <group>
      <name>User</name>
      <file>
        <name>$PROJ_DIR$\..\Src\analys.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\automaticControl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\controlThread.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\Filter.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\freertos.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\pwmIn.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\sensor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f3xx_hal_msp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f3xx_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\systemInit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\watchdog.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Drivers</name>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\CMSIS\Device\ST\STM32F3xx\Source\Templates\system_stm32f3xx.c</name>
      </file>
    </group>
    <group>
      <name>STM32F3xx_HAL_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_cortex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_flash_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_pcd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_pcd_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_pwr_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_rcc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_tim_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F3xx_HAL_Driver\Src\stm32f3xx_hal_uart_ex.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Middlewares</name>
    <group>
      <name>FreeRTOS</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS\cmsis_os.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\croutine.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang\heap_4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F\port.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F\portasm.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\queue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\tasks.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\timers.c</name>
      </file>
    </group>
  </group>
</project>


